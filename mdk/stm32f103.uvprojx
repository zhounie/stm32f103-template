# Keil uVision project stm32f103.uvprojx, settings and files
target project (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f103 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD,NDEBUG
  c include: ..\app\inc;..\driver\led;..\driver\uart;..\firmware\cmsis\core;..\firmware\dirver\inc;..\firmware\cmsis\device;..\third_lib\lettershell;..\third_lib\ringbuffer;..\third_lib\tlsf;..\third_lib\easylogger\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group app
    ../app/: main.c board.c
  group app/commands
    ../app/commands/: mem.c
  group driver
    ../driver/led/: led.c
    ../driver/uart/: uart.c
  group firmware
    ../firmware/cmsis/core/: core_cm3.c
    ../firmware/cmsis/device/: startup_stm32f10x_md.s stm32f10x_it.c system_stm32f10x.c
    ../firmware/dirver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group third_lib
    ../third_lib/lettershell/: shell.c shell_cmd_list.c shell_ext.c
    ../third_lib/ringbuffer/: ringbuffer8.c
    ../third_lib/tlsf/: tlsf.c
    ../third_lib/easylogger/port/: elog_port.c
    ../third_lib/easylogger/src/: elog.c elog_utils.c
